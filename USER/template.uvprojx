# Keil uVision project template.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: template +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10x_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\SYN;..\SYSTEM\Slave;..\SYSTEM\GPIO;..\Gizwits;..\TimBase;..\key;..\Led;..\FATFS;..\lcd;..\sdio;..\lcd;..\flash
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../SYSTEM/SYN/: SYN7318.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/SYN/: UART3.c
    ../SYSTEM/GPIO/: gpio.c
  group Slave
    ../SYSTEM/Slave/: Slave.c
  group WIFI
    ../Gizwits/: common.c dataPointTools.c gizwits_product.c gizwits_protocol.c ringbuffer.c
  group TIM_GENERAL
    ../TimBase/: bsp_GeneralTim.c
  group LED
    ../Led/: bsp_led.h bsp_led.c
  group KEY
    ../key/: bsp_key.c
  group LCD
    ../lcd/: bsp_ili9341_lcd.c
    ../sdio/: fonts.c
    ../flash/: bsp_spi_flash.c
